# Keil uVision project LPCxpresso4337.uvprojx, settings and files
target Internal SRAM (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: LPC1857 NXP
  pack: Keil.LPC1800_DFP.2.10.0
  cpu: IROM(0x1A000000,0x80000) IROM2(0x1B000000,0x80000) IRAM(0x10000000,0x8000) IRAM2(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(180000000) ELITTLE
  output: LPCxpresso4337 +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: CORE_M3 USE_SPIFI_LIB
  c include: .;.\lib;..\Core
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x10000500 size 0x6000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT9: RAM 0x10006500 size 0x1000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group Startup
    ./lib/: startup_LPC18xx.s
  group CMSIS-CM3
    ./lib/: system_LPC18xx.c
  group Drivers
    ./lib/: lpc18xx_scu.c lpc18xx_cgu.c
    ./: spifi_drv_M3.lib
    ../Core/: swd.c
  group Main
    ./: main.c
    ../Core/: bootloader.c
  group Config
    ./: Internal SRAM.ini
  group Flash
    ./: FlashPrg.c

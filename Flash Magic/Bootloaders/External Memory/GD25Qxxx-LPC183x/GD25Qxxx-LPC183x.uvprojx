# Keil uVision project GD25Qxxx-LPC183x.uvprojx, settings and files
target GD25Q16E SRAM (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: LPC1857 NXP
  pack: Keil.LPC1800_DFP.2.11.0
  cpu: IROM(0x1A000000,0x80000) IROM2(0x1B000000,0x80000) IRAM(0x10000000,0x8000) IRAM2(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(180000000) ELITTLE
  output: GD25Q16E-LPC183x +hex
  c flags: Optim=1
  c define: CORE_M3 INTERNALRAM GD25Q16E
  c include: .;.\lib;..\Core
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x10000500 size 0x6000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT9: RAM 0x10006500 size 0x1000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group Startup
    ./lib/: startup_LPC18xx.s
  group CMSIS-CM3
    ./lib/: system_LPC18xx.c
  group Drivers
    ./lib/: lpc18xx_scu.c lpc18xx_cgu.c lpc18xx_uart.c lpc18xx_gpio.c
  group Main
    ./: main.c uart.c
    ../Core/: bootloader.c
  group Config
    ./: Internal SRAM.ini
  group Flash
    ./: FlashPrg.c
target GD25Q16E Flash (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: LPC1857 NXP
  pack: Keil.LPC1800_DFP.2.11.0
  cpu: as above
  output: GD25Q16E-LPC183x-Flash +hex
  AfterMake: $K/ARM/BIN/ElfDwT.exe !L BASEADDRESS(0x1A000000)
  c flags: Optim=1
  c define: CORE_M3 GD25Q16E
  c include: .;.\lib;..\Core
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x1a000000 size 0x6000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT9: RAM 0x10006500 size 0x1000
  memory RVCT10: RAM 0x20000000 size 0x10000
target GD25Q32E SRAM (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: LPC1857 NXP
  pack: Keil.LPC1800_DFP.2.11.0
  cpu: as above
  output: GD25Q32E-LPC183x +hex
  c flags: Optim=1
  c define: CORE_M3 INTERNALRAM GD25Q32E
  c include: .;.\lib;..\Core
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x10000500 size 0x6000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT9: RAM 0x10006500 size 0x1000
  memory RVCT10: RAM 0x20000000 size 0x10000
target GD25Q64E SRAM (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: LPC1857 NXP
  pack: Keil.LPC1800_DFP.2.11.0
  cpu: as above
  output: GD25Q64E-LPC183x +hex
  c flags: Optim=1
  c define: CORE_M3 INTERNALRAM GD25Q64E
  c include: .;.\lib;..\Core
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x10000500 size 0x6000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT9: RAM 0x10006500 size 0x1000
  memory RVCT10: RAM 0x20000000 size 0x10000
target GD25Q128E SRAM (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: LPC1857 NXP
  pack: Keil.LPC1800_DFP.2.11.0
  cpu: as above
  output: GD25Q128E-LPC183x +hex
  c flags: Optim=1
  c define: CORE_M3 INTERNALRAM GD25Q128E
  c include: .;.\lib;..\Core
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x10000500 size 0x6000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT9: RAM 0x10006500 size 0x1000
  memory RVCT10: RAM 0x20000000 size 0x10000
target GD25Q80E SRAM (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: LPC1857 NXP
  pack: Keil.LPC1800_DFP.2.11.0
  cpu: as above
  output: GD25Q80E-LPC183x +hex
  c flags: Optim=1
  c define: CORE_M3 INTERNALRAM GD25Q80E
  c include: .;.\lib;..\Core
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x10000500 size 0x6000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT9: RAM 0x10006500 size 0x1000
  memory RVCT10: RAM 0x20000000 size 0x10000
